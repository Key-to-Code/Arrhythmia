# Keil uVision project ECG_Heart_Analysis.uvprojx, settings and files
target Target_1 (6240000::V6.24::ARMCLANG)
  device: STM32F401CCUx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: ECG_Heart_Analysis
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: .\Core\Inc
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Application/User
    ./Core/Src/: main.c ecg_cnn.c
    ./Core/Inc/: ecg_cnn.h ecg_cnn_weights.h
  group CMSIS
    ./Core/Src/: system_stm32f4xx.c
  group Startup
    ./Drivers/CMSIS/Source/: startup_stm32f401xc.s
software components: CMSIS:CORE 6.2.0
